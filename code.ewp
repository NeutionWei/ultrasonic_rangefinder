# IAR project code.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: User; Lib
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: code.hex
  ILINK.IlinkOutputFile: code.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    Libraries/STM8S_StdPeriph_Driver/inc/: stm8s.h
    Lib/: stm8s_conf.h
  group User
    User/: beep.c detect.c display.c ds18b20.c hc-sr04.c iic.c init.c key.c main.c oled.c typedef.h
